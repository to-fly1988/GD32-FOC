# Keil uVision project gd32Foc.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E503VE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: gd32Foc
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E50X,GD32E50X_HD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\BSP;..\Firmware\CMSIS;..\Firmware\GD32E50x_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32E50x\Include;D:\keil_v5\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: main.c focAlgorithm.c foc_ADC.c foc_usart.c encoder_spi.c foc_tim_pwm.c motor_config.h
  group BSP
    ./BSP/: systick.c gd32e50x_it.c
  group FMW_CORE
    ../Firmware/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../Firmware/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group FMW_PERI
    ../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_spi.c
    ./FMW_PERI/: gd32e50x_adc.c gd32e50x_dma.c
software components: CMSIS:CORE 5.5.0
